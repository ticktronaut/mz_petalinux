SRC_URI += "file://user_2017-07-11-15-20-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

