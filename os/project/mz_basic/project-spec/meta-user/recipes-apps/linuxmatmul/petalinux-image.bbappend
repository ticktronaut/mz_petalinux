IMAGE_INSTALL_append = " linuxmatmul"
